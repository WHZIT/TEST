# Keil uVision project Warenscanner.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Warenscanner
  group Source Group 1
    ./: main.c usart.c usart.h global_defines.h
  group Source CMSIS
    ../CMSIS/CM3_V1P30_Core/: core_cm3.c
    ../CMSIS/CM3_V1P30_LPC17xx/: system_LPC17xx.c
    ../CMSIS/CM3_V1P30_LPC17xx/startup/: startup_LPC17xx.s
